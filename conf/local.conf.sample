## conf/local.conf.sample
```bitbake
DEBIAN_REPOS = "http://ftp.fi.debian.org/debian"
DEBIAN_CODENAME = "stretch"
DEBIAN_ARCH = "amd64"
```
